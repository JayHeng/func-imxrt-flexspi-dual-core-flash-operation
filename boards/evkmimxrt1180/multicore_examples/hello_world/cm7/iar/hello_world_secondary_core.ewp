# IAR project hello_world_secondary_core.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES; MULTICORE_APP=1; MC_CORE1
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/periph; ../../../../../../devices/MIMXRT1189/drivers/cm7; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../components/uart; ../../../../../../middleware/multicore/mcmgr/inc; ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1180
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES
  AARM.AUserIncludes: ..; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/periph; ../../../../../../devices/MIMXRT1189/drivers/cm7; ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1189/utilities/str; ../../../../../../components/silicon_id; ../../../../../../components/silicon_id/socs; ../../../../../../components/uart; ../../../../../../middleware/multicore/mcmgr/inc; ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1180
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: core1_image.bin
  ILINK.IlinkOutputFile: hello_world_secondary_core.out
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES; MULTICORE_APP=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group board
    ../: app.h board.c board.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_iccarm_m.h
  group component
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/silicon_id
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    ../../../../../../components/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm7.h MIMXRT1189_cm7_COMMON.h MIMXRT1189_cm7_features.h system_MIMXRT1189_cm7.c system_MIMXRT1189_cm7.h
  group device/periph
    ../../../../../../devices/MIMXRT1189/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_SYSPM.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group doc
    ../: example_board_readme.md examples_shared_readme.md readme.md
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/cm7/: fsl_cache.c fsl_cache.h
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_mu.c fsl_mu.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h fsl_romapi.c fsl_romapi.h fsl_s3mu.c fsl_s3mu.h fsl_soc_src.c fsl_soc_src.h fsl_trdc.c fsl_trdc.h
  group mcmgr/mcmgr/inc
    ../../../../../../middleware/multicore/mcmgr/inc/: mcmgr.h mcmgr_internal_core_api.h
  group mcmgr/mcmgr/inc/platform/imxrt1180
    ../../../../../../middleware/multicore/mcmgr/inc/platform/imxrt1180/: mcmgr_platform.h
  group mcmgr/mcmgr/src
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
  group source
    ../: clock_config.c clock_config.h main.c mcux_config.h mcuxsdk_version.h
    ../../: flexspi_romapi.c mc_drv.c
  group startup/iar
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../../devices/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
